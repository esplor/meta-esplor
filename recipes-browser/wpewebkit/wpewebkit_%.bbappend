# WPE 2.46.7 has broken compile guards in unified source builds when
# features are stripped — GStreamer GL symbols and VideoFrame references
# fail. Build with defaults until upstream fixes this.
